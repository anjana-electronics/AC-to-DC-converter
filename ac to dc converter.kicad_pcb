# Repository anjana-electronics/AC-to-DC-converter

File README.md:

#AC to DC Converter PCB (KiCad)

 ##Project Overview
This project involves the design of an AC to DC Converter Printed Circuit Board (PCB) using KiCad.
The circuit converts AC input voltage into a regulated DC output suitable for powering electronic devices. 
The PCB layout is designed following standard PCB design rules to ensure safety, reliability, and proper functioning.

##Components Used
1.1N4007 Diodes(Bridge Rectifier)
2.Capacitor: 1000uF
3.Resistors
4.LED Indicator
5.Screw Terminals

##Software Used
 KiCad

 ##Description
 AC input is converted to DC using a bridge rectifier and filtered using a capacitor.
 This PCB is suitable for beginner-level power electronics learning

 ##Working Principle

1.AC Input
AC voltage is applied through a terminal block to the transformer.

2.Rectification
A bridge rectifier converts AC voltage into pulsating DC.

3.Filtering
A capacitor smooths the pulsating DC by reducing ripple voltage.

4.Regulation
The voltage regulator provides a constant DC output.
##PCB Layout

##3D View

## KiCad design ac to dc converter.kicad_pcb

Parts:
C1: 1000uF; C_Radial_D8.0mm_H11.5mm_P3.50mm
D1, D2, D3, D4: 1N4007; D_DO-41_SOD81_P10.16mm_Horizontal
D5: LED; LED_D5.0mm
J1, J2: Screw_Terminal_01x02; Wuerth_691311400102_P7.62mm
R1: 2.2; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R2: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal

Connections:
/+VE: C1.1, D1.1 (K), D2.1 (K), J2.2, R1.1, R2.1
GND: C1.2, D3.2 (A), D4.2 (A), D5.1 (K), J2.1, R2.2
unnamed: D1.2 (A), D3.1 (K), J1.2
unnamed: D2.2 (A), D4.1 (K), J1.1
unnamed: D5.2 (A), R1.2

Notes on the sheet:
12V AC to DC converter

Board: 2 copper layers, 52.5 x 48.0 mm, 10 parts (0 on the bottom side), 5 nets.

## Commit log

2026-02-07 Add files via upload
    Initial commit-AC to DC converter PCB design
